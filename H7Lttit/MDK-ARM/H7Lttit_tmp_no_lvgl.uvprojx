# Keil uVision project H7Lttit_tmp_no_lvgl.uvprojx, settings and files
target H7Lttit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF)       CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: H7Lttit +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,TFT96,LFS_NO_ASSERT,LFS_NO_ERROR,W25Qxx
  c include: ../Inc;../shell/include;../fs/include;../vfs/include;../vim/include;../lib/include;../USB_DEVICE/App;../USB_DEVICE/Target;../LWIP/App;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/LwIP/system/arch;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Middlewares/Third_Party/littlefs;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_RNDIS/Inc;../Drivers/BSP/ST7735;../Drivers/BSP/W25QXX;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x90000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: debug.c main.c gpio.c rtc.c spi.c tim.c quadspi.c qspi_boot.c sdmmc.c littlefs_sd.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group lttit/lib
    ../lib/source/: heap.c prefix.c
  group lttit/fs
    ../fs/source/: fs.c fs_port.c
  group lttit/vfs
    ../vfs/source/: vfs.c vfs_port.c
  group lttit/shell
    ../shell/source/: comm.c shell.c
  group lttit/vim
    ../vim/source/: vim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Drivers/BSP/ST7735
    ../Drivers/BSP/ST7735/: lcd.c st7735.c st7735_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_rndis_if.c
    ../LWIP/App/: usb_rndis_lwip.c
  group USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device/Core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_Device/CDC_RNDIS
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_RNDIS/Src/: usbd_cdc_rndis.c
  group Middlewares/LwIP/Core
    ../Middlewares/Third_Party/LwIP/src/core/: def.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c timeouts.c udp.c
  group Middlewares/LwIP/IPv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Middlewares/FreeRTOS/Core
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
  group Middlewares/littlefs
    ../Middlewares/Third_Party/littlefs/: lfs.c lfs_util.c
  group Middlewares/FreeRTOS/Portable
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.6.0
