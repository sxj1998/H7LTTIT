# Keil uVision project H7Lttit.uvprojx, settings and files
target H7Lttit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF)       CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: H7Lttit +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,TFT96,LFS_NO_ASSERT,LFS_NO_ERROR,W25Qxx,LV_CONF_INCLUDE_SIMPLE,LV_DISABLE_API_MAPPING
  c misc: --diag_suppress=1,68,111,188
  c include: ../Inc;../shell/include;../fs/include;../vfs/include;../vim/include;../lib/include;../USB_DEVICE/App;../USB_DEVICE/Target;../LWIP/App;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/LwIP/system/arch;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Middlewares/Third_Party/littlefs;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_RNDIS/Inc;../Drivers/BSP/ST7735;../Drivers/BSP/W25QXX;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../lvgl_port;../Middlewares/Third_Party/lvgl;../Middlewares/Third_Party/lvgl/src;../Middlewares/Third_Party/lvgl/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x90000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: debug.c main.c gpio.c rtc.c spi.c tim.c quadspi.c qspi_boot.c sdmmc.c littlefs_sd.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group lttit/lib
    ../lib/source/: heap.c prefix.c
  group lttit/fs
    ../fs/source/: fs.c fs_port.c
  group lttit/vfs
    ../vfs/source/: vfs.c vfs_port.c
  group lttit/shell
    ../shell/source/: comm.c shell.c
  group lttit/vim
    ../vim/source/: vim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Drivers/BSP/ST7735
    ../Drivers/BSP/ST7735/: lcd.c st7735.c st7735_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_rndis_if.c
    ../LWIP/App/: usb_rndis_lwip.c
  group USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device/Core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_Device/CDC_RNDIS
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_RNDIS/Src/: usbd_cdc_rndis.c
  group Middlewares/LwIP/Core
    ../Middlewares/Third_Party/LwIP/src/core/: def.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c timeouts.c udp.c
  group Middlewares/LwIP/IPv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Middlewares/FreeRTOS/Core
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
  group Middlewares/littlefs
    ../Middlewares/Third_Party/littlefs/: lfs.c lfs_util.c
  group Middlewares/FreeRTOS/Portable
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group LVGL
    ../lvgl_port/: lv_port_lvgl.c
    ../Middlewares/Third_Party/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/Third_Party/lvgl/src/font/: lv_font.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c
    ../Middlewares/Third_Party/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/Third_Party/lvgl/src/: lv_init.c
    ../Middlewares/Third_Party/lvgl/src/osal/: lv_os.c lv_os_none.c
    ../Middlewares/Third_Party/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../Middlewares/Third_Party/lvgl/src/display/: lv_display.c
    ../Middlewares/Third_Party/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/Third_Party/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/Third_Party/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/Third_Party/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/lvgl/src/themes/: lv_theme.c
    ../Middlewares/Third_Party/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/Third_Party/lvgl/src/tick/: lv_tick.c
    ../Middlewares/Third_Party/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/Third_Party/lvgl/src/widgets/arc/: lv_arc.c
software components: CMSIS:CORE 5.6.0
